# Keil uVision project ACM3800-I.uvprojx, settings and files
target DCM4806_MB (ARM-ADS)
  device: NUC029LAN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.9
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: ACM3800-I-DISP_V11 +hex
  AfterMake: fromelf --bincombined ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\DcMeter_Mini58;.\Library\inc;.\CMSIS;.\User;.\Device
  asm include: .\CMSIS
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_NUC029xAN.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./CMSIS/: system_NUC029xAN.c startup_NUC029xAN.s
  group Library
    ./Library/src/: acmp.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c ebi.c
  group User
    ./User/: AT45DBXXX.c main.c N74HC595.c NRX8010.c RN8209C.c Usart.c UserCommon.c Ydt1363.c SoftTimer.c InfraRecord.c
